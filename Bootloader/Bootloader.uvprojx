# Keil uVision project Bootloader.uvprojx, settings and files
target edge gateway (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c include: ../edge gateway/Core/Inc;../edge gateway/LWIP/App;../edge gateway/LWIP/Target;../edge gateway/Middlewares/Third_Party/LwIP/src/include;../edge gateway/Middlewares/Third_Party/LwIP/system;../edge gateway/Drivers/STM32F4xx_HAL_Driver/Inc;../edge gateway/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../edge gateway/Middlewares/Third_Party/FreeRTOS/Source/include;../edge gateway/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../edge gateway/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../edge gateway/Middlewares/Third_Party/LwIP/src/include/netif/ppp;../edge gateway/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../edge gateway/Middlewares/Third_Party/LwIP/src/include/lwip;../edge gateway/Middlewares/Third_Party/LwIP/src/include/lwip/apps;../edge gateway/Middlewares/Third_Party/LwIP/src/include/lwip/priv;../edge gateway/Middlewares/Third_Party/LwIP/src/include/lwip/prot;../edge gateway/Middlewares/Third_Party/LwIP/src/include/netif;../edge gateway/Middlewares/Third_Party/LwIP/src/include/compat/posix;../edge gateway/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa;../edge gateway/Middlewares/Third_Party/LwIP/src/include/compat/posix/net;../edge gateway/Middlewares/Third_Party/LwIP/src/include/compat/posix/sys;../edge gateway/Middlewares/Third_Party/LwIP/src/include/compat/stdc;../edge gateway/Middlewares/Third_Party/LwIP/system/arch;../edge gateway/Drivers/CMSIS/Include
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ./: main_bl.c system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
